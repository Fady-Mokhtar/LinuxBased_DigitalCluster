SUMMARY = "A psplash customization recipe"
DESCRIPTION ="This recipe allows personalization of pshlash colors and image"
LICENSE = "Closed"
LIC_FILES_CHKSUM = " "

SPLASH_IMAGE_NAME = "logo.png"

BACKGROUND_COLOR = "0x00,0x00, 0x00"
TEXT_COLOR  = "0x00,0x00, 0x00"
BAR_COLOR = "0x00,0xff, 0x00"
BAR_BACKGROUND_COLOR = "0x00,0x00, 0x00"

MACHINE_PSPLASH_PKG:rpi = "raspberrypi"
